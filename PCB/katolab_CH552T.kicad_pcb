# Repository katolabmain/KatoLab_KeyHolder

## KiCad design PCB/katolab_CH552T.kicad_pcb

Parts:
C1, C2, C3, C5, C6, C7, C8: 0.1uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D2: LED_GBKR; LED_D5.0mm-4_RGB_Wide_Pins
IC1: S-1142B50I-E6T1U; S1142D33IE6T1U; Mouser Part Number 628-S-1142B50I-E6T1U
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J2: Conn_01x02; AMASS_XT30U-F_1x02_P5.0mm_Vertical
J3: Conn_01x06; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
R1: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R4, R6, R7, R8, R9, R12: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R5, R10, R11: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1, SW3, SW5, SW6: SW_SPDT; swich_SS-12D00G3
SW2, SW4, SW7, SW8: SW_MEC_5E; THAU13-AB-R
U1: CH224K; SSOP-10-1EP_3.9x4.9mm_P1mm_EP2.1x3.3mm
U2: CH552T; TSSOP-20_4.4x6.5mm_P0.65mm
U4: TC74VHC00F; SO-14_5.3x10.2mm_P1.27mm
U6: TC7WZ07FK; VSSOP-8_2.3x2mm_P0.5mm

Connections:
+3.3V: C6.1, C7.1, C8.1, J3.2, R6.2, R7.2, SW1.1 (A), SW3.3 (C), SW5.3 (C), SW6.3 (C), SW7.1, SW7.2, U2.20 (3.3V), U4.14 (VDD), U6.8 (VCC)
+5V: C2.1, C5.1, IC1.6 (VIN), R3.1, SW8.3 (K), SW8.4 (A), U2.19 (VCC)
CFG1: R4.2, U1.9 (CFG1), U6.7
CFG2: R8.2, U1.2 (CFG2), U6.2
CFG3: R9.2, U1.3 (CFG3), U6.5
D+: J1.A6 (D+), J1.B6 (D+), R12.1, U2.14 (P3.6/D+)
D-: J1.A7 (D-), J1.B7 (D-), U2.15 (P3.7/D-)
GNDD: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, D2.3 (K), IC1.2 (VSS_1), IC1.5 (VSS_2), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J2.1, J3.1, SW1.3 (C), SW2.3 (K), SW2.4 (A), SW4.3 (K), SW4.4 (A), U1.11 (GND), U2.18 (GND), U4.7 (VSS), U4.12, U4.13, U6.4 (GND)
IN1: U2.5 (P1.7), U4.2
IN2: U2.7 (P1.0), U4.6
IN3: U2.8 (P1.1), U4.9
LED1: R5.1, U2.1 (P3.2)
LED2: R10.1, U2.13 (P3.5)
LED3: R11.1, U2.11 (P3.3)
unnamed: D1.2 (A), R3.2
unnamed: D1.1 (K), U1.10 (PG)
unnamed: D2.2 (BA), R11.2
unnamed: D2.1 (GA), R10.2
unnamed: D2.4 (RA), R5.2
unnamed: J1.A5 (CC1), U1.7 (CC1)
unnamed: J1.B5 (CC2), U1.6 (CC2)
unnamed: R4.1, SW3.2 (B)
unnamed: R8.1, SW5.2 (B)
unnamed: R9.1, SW6.2 (B)
unnamed: R12.2, SW7.3 (K), SW7.4 (A)
unnamed: U1.4 (DP), U1.5 (DM)
unnamed: R2.2, U1.8 (VBUS)
unnamed: C4.1, R1.2, U1.1 (VDD)
unnamed: U4.3, U6.1
unnamed: U4.4, U6.6
unnamed: U4.10, U6.3
PWM1: J3.3, U2.12 (P3.4)
PWM2: J3.4, U2.3 (P1.5)
RST: SW8.1, SW8.2, U2.6 (RST)
RXD: J3.6, U2.10 (P3.0)
TXD: J3.5, U2.9 (P3.1)
VBUS: C1.1, C3.1, IC1.1 (VOUT), IC1.3 (ON_/_OFF), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J2.2, R1.1, R2.1
free-sw1: R6.1, SW2.1, SW2.2, U2.2 (P1.4)
free-sw2: R7.1, SW4.1, SW4.2, U2.4 (P1.6)
sw_V: SW1.2 (B), SW3.1 (A), SW5.1 (A), SW6.1 (A), U4.1, U4.5, U4.8

Notes on the sheet:
マイコン用
+------+------+------+-----------------+ | CFG1 | CFG2 | CFG3 | Request-voltage | +------+------+------+-----------------+ | 1 | - | - | 5 V | +------+------+------+-----------------+ | 0 | 0 | 0 | 9 V | +------+------+------+-----------------+ | 0 | 0 | 1 | 12 V | +------+------+------+-----------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
スイッチ用

Board: 2 copper layers, 40.0 x 40.0 mm, 38 parts (0 on the bottom side), 40 nets.
